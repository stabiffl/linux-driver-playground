## drivers/net/bshdbus/Kconfig
```kconfig
# SPDX-License-Identifier: GPL-2.0-only
menu "BSH D-Bus Drivers"

source "drivers/net/bshdbus/dbus2/Kconfig"

endmenu
```
